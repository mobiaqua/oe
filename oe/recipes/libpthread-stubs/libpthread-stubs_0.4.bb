require libpthread-stubs.inc
PR = "${INC_PR}.0"

SRC_URI[md5sum] = "48c1544854a94db0e51499cc3afd797f"
SRC_URI[sha256sum] = "e4d05911a3165d3b18321cc067fdd2f023f06436e391c6a28dff618a78d2e733"
