include zlib.inc

PR = "${INC_PR}.0"

SRC_URI += "file://0001-autotools.patch "

SRC_URI[md5sum] = "c735eab2d659a96e5a594c9e8541ad63"
SRC_URI[sha256sum] = "6064e52e513facb0fbb7998c6413406cf253cfb986063d68f4771c2bf7a3f958"

DEFAULT_PREFERENCE = "-1"
