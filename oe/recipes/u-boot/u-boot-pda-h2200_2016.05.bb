UBOOT_MACHINE = "h2200_config"

require u-boot-pda_2016.05.inc
