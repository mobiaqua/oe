require dtc.inc

SRCREV = "b06e55c88b9b922ff7e25cd62a4709b65524f0fc"
PV = "1.4.1+git${SRCPV}"

S = "${WORKDIR}/git"

BBCLASSEXTEND = "native"
